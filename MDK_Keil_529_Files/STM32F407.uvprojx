# Keil uVision project STM32F407.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ILI9486_STM32F407
  c flags: Optim=7 uC99=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: .\Delay_CMSIS;.\User;.\ILI9486_Lib;.\ILI9486_Lib\Fonts;.\ILI9486_Lib\Image
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./User/: main.c main.h Init_CMSIS.c Interrupt.c
  group Delay
    ./Delay_CMSIS/: Delay.c Delay.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:EXTI 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:RTC 1.7.6, Device:STM32Cube HAL:TIM 1.7.6, Device:Startup 2.6.3
